# Keil uVision project THE_CLOCK_VER1.2.uvprojx, settings and files
target THE_CLOCK_VER1.2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: THE_CLOCK_VER1.2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../libUserCreate/application;../libUserCreate/buz;../libUserCreate/eeprom;../libUserCreate/lcd_menu;../libUserCreate/led;../libUserCreate/rtc;../libUserCreate/temp;../libUserCreate/uart_ring_buffer;../libUserCreate/gpio;../libUserCreate/button
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group libUser_driver
    ../libUserCreate/application/: global.c button_app.c buzzer_led_app.c lcd_menu_app.c ds1307_button_app.c ds1307_lcd_app.c temp_lcd_app.c temp_button_app.c ee_app.c uart_button_app.c uart_lcd_app.c alarm_app.c
  group libUser_divice
    ../libUserCreate/buz/: buzzer.c
    ../libUserCreate/eeprom/: ee.c
    ../libUserCreate/lcd_menu/: lcd.c lcd_menu.c
    ../libUserCreate/led/: led.c
    ../libUserCreate/rtc/: ds1307.c
    ../libUserCreate/temp/: ds18b20.c
    ../libUserCreate/uart_ring_buffer/: uart.c
    ../libUserCreate/gpio/: gpio_stm32.c
    ../libUserCreate/button/: button.c
software components: CMSIS:CORE 4.3.0
